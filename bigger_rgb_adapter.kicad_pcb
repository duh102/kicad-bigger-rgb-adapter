# Repository duh102/kicad-bigger-rgb-adapter

## KiCad design bigger_rgb_adapter.kicad_pcb

Board: 2 copper layers, 11.4 x 26.7 mm, 7 parts (2 on the bottom side), 20 nets.

Parts:
D1, D2, D3, D4, D5: LED_BGRA; LED_RGB_EAST1616RGBA3
J1, J2: Conn_01x10; PinHeader_1x10_P2.54mm_Vertical

Connections:
unnamed: D1.1, J2.10
unnamed: D1.2, J2.9
unnamed: D1.3, J1.9
unnamed: D1.4, J1.10
unnamed: D2.1, J2.8
unnamed: D2.2, J2.7
unnamed: D2.3, J1.7
unnamed: D2.4, J1.8
unnamed: D3.1, J2.6
unnamed: D3.2, J2.5
unnamed: D3.3, J1.5
unnamed: D3.4, J1.6
unnamed: D4.1, J2.4
unnamed: D4.2, J2.3
unnamed: D4.3, J1.3
unnamed: D4.4, J1.4
unnamed: D5.1, J2.2
unnamed: D5.2, J2.1
unnamed: D5.3, J1.1
unnamed: D5.4, J1.2

## Commit log

2019-09-23 Use EAST1616RGBA3 LEDs instead
